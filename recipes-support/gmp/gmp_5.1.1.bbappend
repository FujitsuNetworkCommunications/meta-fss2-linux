FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://protected-to-hidden.patch"
PR := "${PR}.2"
